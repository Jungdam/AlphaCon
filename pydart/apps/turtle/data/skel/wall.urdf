Commit message: View class modified

File: pydart/apps/turtle/data/skel/wall.urdf (robot description, URDF)
Before this commit: robot wall, 2 links, 1 joints
Joints:
- joint joint: origin xyz=0 0 5 rpy=0 0 0 -> xyz=0 -5 20 rpy=0 0 0
